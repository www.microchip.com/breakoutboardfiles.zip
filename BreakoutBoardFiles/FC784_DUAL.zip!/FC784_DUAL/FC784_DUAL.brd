# Allegro board FC784_DUAL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IO317: length 6
  TOP w0.254: U1.AD4 v1(43.81,49.23)
  L3_SIG1 w0.102: 38.76,48.63 42.78,48.63 43.39,49.23 v1(43.81,49.23)
IO318: length 5.5
  TOP w0.254: U1.AD5 v1(44.81,49.23)
  L3_SIG1 w0.102: v1(44.81,49.23) 44.5,49.23 44.11,48.84 43.3,48.84 42.87,48.41 40.39,48.41
IO319: length 6
  TOP w0.254: U1.AD6 v1(45.81,49.23)
  L3_SIG1 w0.102: 43.74,44.76 44.77,45.79 44.77,48.19 v1(45.81,49.23)
IO320: length 5.1
  TOP w0.254: U1.AD8 v1(47.81,49.23)
  L3_SIG1 w0.102: 46.98,45.16 46.98,48.4 v1(47.81,49.23)
IO321: length 5
  TOP w0.254: U1.AD9 v1(48.81,49.23)
  L3_SIG1 w0.102: v1(48.81,49.23) 48.81,48.79 48.42,48.39 48.42,45.06
IO322: length 5.2
  TOP w0.254: U1.AD10 v1(49.81,49.23)
  L3_SIG1 w0.102: 49.08,45.04 49.08,47.43 49.42,47.77 49.42,48.84 v1(49.81,49.23)
IO323: length 7
  TOP w0.254: U1.AD11 v1(50.81,49.23)
  L3_SIG1 w0.102: 51.42,43.18 51.42,47.77 51.21,47.98 51.21,48.84 v1(50.81,49.23)
IO324: length 6.7
  TOP w0.254: U1.AD13 v1(52.81,49.23)
  L3_SIG1 w0.102: v1(52.81,49.23) 53.2,48.84 53.2,46.91 53.69,46.42 53.69,43.61
IO325: length 7
  TOP w0.254: U1.AD14 v1(53.81,49.23)
  L3_SIG1 w0.102: v1(53.81,49.23) 54.42,48.63 54.42,43.18
IO326: length 6.4
  TOP w0.254: U1.AD15 v1(55.81,49.23)
  L3_SIG1 w0.102: v1(55.81,49.23) 55.42,48.84 55.42,48.4 55.42,48.39 55.42,48.07 55.42,46.16 55.98,45.6 55.98,43.98
IO327: length 6.3
  TOP w0.254: U1.AD16 v1(56.81,49.23)
  L3_SIG1 w0.102: v1(56.81,49.23) 57.21,48.84 57.21,43.86 57.22,43.85
IO328: length 7
  TOP w0.254: U1.AD18 v1(58.81,49.23)
  L3_SIG1 w0.102: v1(58.81,49.23) 58.81,48.79 59.2,48.39 59.2,46.92 59.42,46.71 59.42,43.23
IO329: length 7.2
  TOP w0.254: U1.AD19 v1(59.81,49.23)
  L3_SIG1 w0.102: 60.9,43.23 60.9,45.36 60.2,46.05 60.2,48.84 v1(59.81,49.23)
IO330: length 6.2
  TOP w0.254: U1.AD20 v1(60.81,49.23)
  L3_SIG1 w0.102: v1(60.81,49.23) 61.42,48.63 61.42,46.6 61.88,46.14 61.88,44.18
IO331: length 7
  TOP w0.254: U1.AD21 v1(61.81,49.23)
  L3_SIG1 w0.102: v1(61.81,49.23) 61.81,48.79 62.2,48.39 62.2,47.72 62.42,47.51 62.42,43.18
IO332: length 2.4
  TOP w0.127: U1.AE1 38.9,48.73
IO333: length 3.6
  TOP w0.127: 38.9,48.34 41.92,48.34 U1.AE2
IO334: length 4.7
  TOP w0.127: U1.AE3 42.93,48.35 42.24,48.35 42.01,48.12 38.9,48.12
IO335: length 6.6
  TOP w0.127: 43.7,43.15 43.7,46.89 44.06,47.25 44.57,47.25 44.86,47.53 44.86,48.27 45.31,48.72 U1.AE5
IO336: length 4.4
  TOP w0.254: U1.AE6 v1(45.81,48.23)
  L3_SIG1 w0.102: v1(45.81,48.23) 45.16,47.58 45.16,45.63 44.6,45.06
IO337: length 6.3
  TOP w0.127: 46.04,43.06 46.04,45.46 45.93,45.57 45.93,45.89 46.15,46.12 46.25,46.12 46.7,46.57 46.7,48.12 U1.AE7
IO338: length 4
  TOP w0.254: U1.AE8 v1(47.81,48.23)
  L3_SIG1 w0.102: 47.4,45.15 47.4,47.82 v1(47.81,48.23)
IO339: length 4.1
  TOP w0.254: U1.AE10 v1(49.81,48.23)
  L3_SIG1 w0.102: 49.47,45.01 49.47,47.38 49.81,47.72 v1(49.81,48.23)
IO340: length 5.9
  TOP w0.254: U1.AE11 v1(50.81,48.23)
  L3_SIG1 w0.102: 51.2,43.18 51.2,47.39 50.81,47.79 v1(50.81,48.23)
IO341: length 5.8
  TOP w0.254: U1.AE12 v1(51.81,48.23)
  L3_SIG1 w0.102: 51.88,43.19 51.88,48.16 v1(51.81,48.23)
IO342: length 5.5
  TOP w0.254: U1.AE13 v1(52.81,48.23)
  L3_SIG1 w0.102: v1(52.81,48.23) 52.81,47 53.42,46.4 53.42,43.65
IO343: length 5.9
  TOP w0.254: U1.AE15 v1(55.81,48.23)
  L3_SIG1 w0.102: v1(55.81,48.23) 55.81,47.79 56.2,47.39 56.2,43.23
IO344: length 5.1
  TOP w0.254: U1.AE16 v1(56.81,48.23)
  L3_SIG1 w0.102: 56.97,43.88 56.97,47.69 56.81,47.84 v1(56.81,48.23)
IO345: length 4.8
  TOP w0.254: U1.AE17 v1(57.81,48.23)
  L3_SIG1 w0.102: 58.2,44.31 58.2,46.51 57.81,46.9 v1(57.81,48.23)
IO346: length 5.9
  TOP w0.254: U1.AE18 v1(58.81,48.23)
  L3_SIG1 w0.102: v1(58.81,48.23) 58.81,47 59.2,46.61 59.2,43.23
IO347: length 5.1
  TOP w0.254: U1.AE20 v1(60.81,48.23)
  L3_SIG1 w0.102: 61.67,44.18 61.67,46.05 61.2,46.51 61.2,47.84 v1(60.81,48.23)
IO348: length 5.9
  TOP w0.254: U1.AE21 v1(61.81,48.23)
  L3_SIG1 w0.102: v1(61.81,48.23) 61.81,47.79 62.2,47.39 62.2,43.18
IO349: length 2.4
  TOP w0.127: U1.AF1 38.9,47.73
IO350: length 3.6
  TOP w0.127: 38.9,47.34 41.53,47.34 41.92,47.73 U1.AF2
IO351: length 4.7
  TOP w0.127: U1.AF3 42.93,47.35 41.93,47.35 41.7,47.12 38.9,47.12
IO352: length 6.1
  TOP w0.127: 38.9,46.28 41.46,46.28 41.7,46.53 41.7,46.66 42.15,47.12 43.38,47.12 43.99,47.73 U1.AF4
IO353: length 4.9
  TOP w0.127: 44.61,43.15 44.61,45.32 44.7,45.4 44.7,46.77 45.31,47.39 U1.AF5
IO354: length 4.9
  TOP w0.127: 46.7,43.06 46.7,46.26 46.93,46.49 46.93,47.35 U1.AF7
IO355: length 4.6
  TOP w0.127: U1.AF8 48.7,47.35 48.7,43.33
IO356: length 4.6
  TOP w0.127: U1.AF9 49.7,47.35 49.7,45.57 49.57,45.44 49.57,43.33
IO357: length 4.6
  TOP w0.127: U1.AF10 49.92,47.34 49.92,45.48 49.79,45.35 49.79,43.33
IO358: length 4.7
  TOP w0.127: U1.AF12 51.93,47.35 51.93,46.66 51.7,46.43 51.7,43.33
IO359: length 4.6
  TOP w0.127: U1.AF13 53.7,47.35 53.7,43.27
IO360: length 4.7
  TOP w0.127: U1.AF14 54.7,47.35 54.7,45.57 54.56,45.43 54.56,43.27
IO361: length 4.7
  TOP w0.127: 54.83,43.27 54.83,45.39 54.92,45.48 54.92,47.34 U1.AF15
IO362: length 4.7
  TOP w0.127: 56.7,43.27 56.7,46.43 56.93,46.66 56.93,47.35 U1.AF17
IO363: length 4.6
  TOP w0.127: 58.7,43.32 58.7,47.35 U1.AF18
IO364: length 4.6
  TOP w0.127: 59.59,43.32 59.59,45.47 59.7,45.57 59.7,47.35 U1.AF19
IO365: length 4.6
  TOP w0.127: 59.81,43.32 59.81,45.38 59.92,45.48 59.92,47.34 U1.AF20
IO366: length 2.4
  TOP w0.127: U1.AG1 38.9,46.73
IO367: length 3.8
  TOP w0.127: U1.AG2 41.81,46.23 41.81,43.15
IO368: length 3.7
  TOP w0.127: U1.AG4 43.92,46.34 43.92,43.15
IO369: length 3.8
  TOP w0.127: U1.AG5 44.93,46.35 44.93,45.32 44.83,45.22 44.83,43.15
IO370: length 4
  TOP w0.127: U1.AG6 45.71,46.13 45.71,45.48 45.81,45.37 45.81,43.06
IO371: length 3.8
  TOP w0.127: 46.92,43.06 46.92,46.01 47.31,46.41 U1.AG7
IO372: length 3.6
  TOP w0.127: 48.92,43.33 48.92,46.34 U1.AG9
IO373: length 3.6
  TOP w0.127: U1.AG10 50.7,46.35 50.7,45.32 50.79,45.22 50.79,43.33
IO374: length 3.6
  TOP w0.127: U1.AG11 50.92,46.34 50.92,45.41 51.01,45.32 51.01,43.33
IO375: length 3.6
  TOP w0.127: 51.92,43.33 51.92,46.34 U1.AG12
IO376: length 3.6
  TOP w0.127: 53.92,43.27 53.92,46.34 U1.AG14
IO377: length 3.7
  TOP w0.127: 55.79,43.27 55.79,45.22 55.7,45.32 55.7,46.35 U1.AG15
IO378: length 3.7
  TOP w0.127: U1.AG16 55.92,46.34 55.92,45.41 56.01,45.32 56.01,43.27
IO379: length 3.6
  TOP w0.127: 56.92,43.27 56.92,46.34 U1.AG17
IO380: length 3.6
  TOP w0.127: U1.AG19 58.92,46.34 58.92,43.32
IO381: length 3.2
  TOP w0.127: 60.79,43.76 60.79,45.22 60.7,45.32 60.7,46.35 U1.AG20
IO382: length 3.3
  TOP w0.127: 61.01,43.59 61.01,45.32 60.92,45.41 60.92,46.34 U1.AG21
IO383: length 3.6
  TOP w0.127: 61.81,43.39 61.81,46.23 U1.AG22
IO384: length 2.6
  TOP w0.127: U1.AH2 42.31,43.15
IO385: length 2.6
  TOP w0.127: U1.AH3 43.31,43.15
IO386: length 2.6
  TOP w0.127: U1.AH4 44.31,43.15
IO387: length 2.7
  TOP w0.127: U1.AH6 46.31,43.06
IO388: length 2.7
  TOP w0.127: U1.AH7 47.31,43.06
IO389: length 2.4
  TOP w0.127: U1.AH8 48.31,43.33
IO390: length 2.4
  TOP w0.127: U1.AH9 49.31,43.33
IO391: length 2.4
  TOP w0.127: U1.AH11 51.31,43.33
IO392: length 2.4
  TOP w0.127: U1.AH12 52.31,43.33
IO393: length 2.5
  TOP w0.127: U1.AH13 53.31,43.27
IO394: length 2.5
  TOP w0.127: U1.AH14 54.31,43.27
IO395: length 2.5
  TOP w0.127: U1.AH16 56.31,43.27
IO396: length 2.5
  TOP w0.127: U1.AH17 57.31,43.27
IO397: length 2.4
  TOP w0.127: U1.AH18 58.31,43.32
IO398: length 2.4
  TOP w0.127: U1.AH19 59.31,43.32
IO399: length 2.3
  TOP w0.127: U1.AH21 61.31,43.39
IO400: length 2.3
  TOP w0.127: U1.AH22 62.31,43.39
IO401: length 2.3
  TOP w0.127: U1.AH23 63.31,43.39
SERDES_0_INT_REFCLK_N: length 6.7
  TOP w0.254: U1.R24 v1(63.81,59.23)
  L4_SIG2 w0.102: 69.67,59.61 64.19,59.61 v1(63.81,59.23)
SERDES_0_INT_REFCLK_P: length 7.8
  TOP w0.254: U1.R23 v1(62.81,59.23)
  L4_SIG2 w0.102: v1(62.81,59.23) 63.44,59.86 69.67,59.86
SERDES_0_RX0_N: length 7.6
  TOP w0.254: U1.T26 v1(66.81,57.23)
  L3_SIG1 w0.127: v1(66.81,57.23) 67.44,57.86 73.41,57.86
SERDES_0_RX0_P: length 8.7
  TOP w0.254: U1.T25 v1(65.81,57.23)
  L3_SIG1 w0.127: 73.41,58.14 67.32,58.14 66.92,57.73 66.31,57.73 v1(65.81,57.23)
SERDES_0_RX1_N: length 7.5
  TOP w0.254: U1.V26 v1(66.81,55.23)
  L3_SIG1 w0.127: 73.41,55.82 67.61,55.82 67.02,55.23 v1(66.81,55.23)
SERDES_0_RX1_P: length 8.7
  TOP w0.254: U1.V25 v1(65.81,55.23)
  L3_SIG1 w0.127: 73.41,56.1 67.5,56.1 67.12,55.73 66.31,55.73 v1(65.81,55.23)
SERDES_0_RX2_N: length 7.6
  TOP w0.254: U1.Y26 v1(66.81,53.23)
  L3_SIG1 w0.127: v1(66.81,53.23) 66.98,53.23 67.7,53.95 73.41,53.95
SERDES_0_RX2_P: length 8.7
  TOP w0.254: U1.Y25 v1(65.81,53.23)
  L3_SIG1 w0.127: v1(65.81,53.23) 66.31,53.73 67.09,53.73 67.59,54.23 73.41,54.23
SERDES_0_RX3_N: length 7.5
  TOP w0.254: U1.AB26 v1(66.81,51.23)
  L3_SIG1 w0.127: 73.41,51.77 67.63,51.77 67.09,51.23 v1(66.81,51.23)
SERDES_0_RX3_P: length 8.6
  TOP w0.254: U1.AB25 v1(65.81,51.23)
  L3_SIG1 w0.127: v1(65.81,51.23) 66.31,51.73 67.2,51.73 67.52,52.05 73.41,52.05
SERDES_0_TX0_N: length 8.5
  TOP w0.127: 76.62,58.17 69.36,58.17 68.97,58.56 68.48,58.56 U1.R28
SERDES_0_TX0_P: length 9.7
  TOP w0.127: 76.62,57.84 69.22,57.84 68.83,58.23 67.81,58.23 U1.R27
SERDES_0_TX1_N: length 8.5
  TOP w0.127: 76.62,56.17 69.36,56.17 68.97,56.56 68.48,56.56 U1.U28
SERDES_0_TX1_P: length 9.7
  TOP w0.127: U1.U27 67.81,56.23 68.83,56.23 69.22,55.84 76.62,55.84
SERDES_0_TX2_N: length 8.5
  TOP w0.127: 76.62,54.17 69.36,54.17 68.97,54.56 68.48,54.56 U1.W28
SERDES_0_TX2_P: length 9.7
  TOP w0.127: U1.W27 67.81,54.23 68.83,54.23 69.22,53.84 76.62,53.84
SERDES_0_TX3_N: length 8.5
  TOP w0.127: U1.AA28 68.48,52.56 68.97,52.56 69.36,52.17 76.62,52.17
SERDES_0_TX3_P: length 9.7
  TOP w0.127: 76.62,51.84 69.22,51.84 68.83,52.23 67.81,52.23 U1.AA27
SERDES_0N_EXT_REFCLK_N: length 8.6
  TOP w0.254: U1.T22 v1(62.81,57.23)
  L4_SIG2 w0.102: v1(62.81,57.23) 62.49,57.56 62.49,57.86 62.64,58.01 69.55,58.01
SERDES_0N_EXT_REFCLK_P: length 9.1
  TOP w0.254: U1.T21 v1(61.81,57.23)
  L4_SIG2 w0.102: v1(61.81,57.23) 62.24,57.65 62.24,57.97 62.53,58.26 69.55,58.26
SERDES_0S_EXT_REFCLK_N: length 7.7
  TOP w0.254: U1.P22 v1(62.81,60.23)
  L4_SIG2 w0.102: 69.63,60.6 63.19,60.6 v1(62.81,60.23)
SERDES_0S_EXT_REFCLK_P: length 8.8
  TOP w0.254: U1.P21 v1(61.81,60.23)
  L4_SIG2 w0.102: 69.63,60.86 62.44,60.86 v1(61.81,60.23)
SERDES_01_EXT_REFCLK_N: length 5.8
  TOP w0.254: U1.N24 v1(64.81,61.23)
  L4_SIG2 w0.102: v1(64.81,61.23) 65.18,61.6 69.74,61.6
SERDES_01_EXT_REFCLK_P: length 6.9
  TOP w0.254: U1.N23 v1(63.81,61.23)
  L4_SIG2 w0.102: 69.74,61.86 64.44,61.86 v1(63.81,61.23)
SERDES_1_INT_REFCLK_N: length 7.7
  TOP w0.254: U1.M22 v1(62.81,62.23)
  L4_SIG2 w0.102: 69.67,62.6 63.18,62.6 v1(62.81,62.23)
SERDES_1_INT_REFCLK_P: length 8.8
  TOP w0.254: U1.M21 v1(61.81,62.23)
  L4_SIG2 w0.102: v1(61.81,62.23) 62.44,62.85 69.67,62.85
SERDES_1_RX0_N: length 8.6
  TOP w0.254: U1.H25 v1(65.81,66.23)
  L3_SIG1 w0.127: 73.41,65.42 67.44,65.42 67.12,65.73 66.31,65.73 v1(65.81,66.23)
SERDES_1_RX0_P: length 7.5
  TOP w0.254: U1.H26 v1(66.81,66.23)
  L3_SIG1 w0.127: v1(66.81,66.23) 67.09,66.23 67.63,65.7 73.41,65.7
SERDES_1_RX1_N: length 8.7
  TOP w0.254: U1.K25 v1(65.81,64.23)
  L3_SIG1 w0.127: 73.41,63.31 67.54,63.31 67.12,63.73 66.31,63.73 v1(65.81,64.23)
SERDES_1_RX1_P: length 7.6
  TOP w0.254: U1.K26 v1(66.81,64.23)
  L3_SIG1 w0.127: 73.41,63.59 67.66,63.59 67.01,64.23 v1(66.81,64.23)
SERDES_1_RX2_N: length 8.7
  TOP w0.254: U1.M25 v1(65.81,62.23)
  L3_SIG1 w0.127: v1(65.81,62.23) 66.31,61.73 67.11,61.73 67.58,61.26 73.41,61.26
SERDES_1_RX2_P: length 7.6
  TOP w0.254: U1.M26 v1(66.81,62.23)
  L3_SIG1 w0.127: 73.41,61.54 67.69,61.54 67.01,62.23 v1(66.81,62.23)
SERDES_1_RX3_N: length 8.7
  TOP w0.254: U1.P25 v1(65.81,60.23)
  L3_SIG1 w0.127: 73.41,59.39 67.47,59.39 67.12,59.73 66.31,59.73 v1(65.81,60.23)
SERDES_1_RX3_P: length 7.5
  TOP w0.254: U1.P26 v1(66.81,60.23)
  L3_SIG1 w0.127: 73.41,59.66 67.59,59.66 67.02,60.23 v1(66.81,60.23)
SERDES_1_TX0_N: length 9.7
  TOP w0.127: U1.G27 67.81,67.23 68.83,67.23 69.22,67.62 76.62,67.62
SERDES_1_TX0_P: length 8.5
  TOP w0.127: 76.62,67.29 69.36,67.29 68.97,66.9 68.48,66.9 U1.G28
SERDES_1_TX1_N: length 9.7
  TOP w0.127: 76.62,65.62 69.22,65.62 68.83,65.23 67.81,65.23 U1.J27
SERDES_1_TX1_P: length 8.5
  TOP w0.127: U1.J28 68.48,64.9 68.97,64.9 69.36,65.29 76.62,65.29
SERDES_1_TX2_N: length 9.7
  TOP w0.127: U1.L27 67.81,63.23 68.83,63.23 69.22,63.62 76.62,63.62
SERDES_1_TX2_P: length 8.5
  TOP w0.127: 76.62,63.29 69.36,63.29 68.97,62.9 68.48,62.9 U1.L28
SERDES_1_TX3_N: length 9.7
  TOP w0.127: 76.62,61.62 69.22,61.62 68.83,61.23 67.81,61.23 U1.N27
SERDES_1_TX3_P: length 8.5
  TOP w0.127: U1.N28 68.48,60.9 68.97,60.9 69.36,61.29 76.62,61.29
SERDES_02_EXT_REFCLK_N: length 5.7
  TOP w0.254: U1.U24 v1(64.81,56.23)
  L4_SIG2 w0.102: 69.63,56.61 65.19,56.61 v1(64.81,56.23)
SERDES_02_EXT_REFCLK_P: length 6.8
  TOP w0.254: U1.U23 v1(63.81,56.23)
  L4_SIG2 w0.102: 69.63,56.86 64.44,56.86 v1(63.81,56.23)
SERDES_2_INT_REFCLK_N: length 5.7
  TOP w0.254: U1.W24 v1(64.81,54.23)
  L4_SIG2 w0.102: 69.69,54.6 65.18,54.6 v1(64.81,54.23)
SERDES_2_INT_REFCLK_P: length 6.8
  TOP w0.254: U1.W23 v1(63.81,54.23)
  L4_SIG2 w0.102: 69.69,54.86 64.44,54.86 v1(63.81,54.23)
SERDES_2_RX0_N: length 10.7
  TOP w0.254: U1.AC23 v1(63.81,50.23)
  L3_SIG1 w0.127: v1(63.81,50.23) 64.31,49.74 67.08,49.74 67.51,50.16 73.4,50.16
SERDES_2_RX0_P: length 9.6
  TOP w0.254: U1.AC24 v1(64.81,50.23)
  L3_SIG1 w0.127: 73.4,50.44 67.42,50.44 67.13,50.73 65.31,50.73 v1(64.81,50.23)
SERDES_2_RX1_N: length 14.1
  TOP w0.254: U1.AE24 v1(64.81,48.23)
  L3_SIG1 w0.127: 73.55,44.41 64.36,44.41 64.11,44.66 64.11,47.33 64.43,47.66 64.43,47.85 v1(64.81,48.23)
SERDES_2_RX1_P: length 14.5
  TOP w0.254: U1.AE23 v1(63.81,48.23)
  L3_SIG1 w0.127: 73.55,44.13 64.24,44.13 63.83,44.54 63.83,47.44 64.1,47.72 64.1,47.94 v1(63.81,48.23)
SERDES_2_RX2_N: length 7.6
  TOP w0.254: U1.AF26 v1(66.81,47.23)
  L3_SIG1 w0.127: 73.41,46.44 67.88,46.44 67.09,47.23 v1(66.81,47.23)
SERDES_2_RX2_P: length 8.7
  TOP w0.254: U1.AF25 v1(65.81,47.23)
  L3_SIG1 w0.127: 73.41,46.16 67.76,46.16 67.2,46.73 66.31,46.73 v1(65.81,47.23)
SERDES_2_RX3_N: length 12.1
  TOP w0.127: U1.AH26 65.98,45.4 65.98,44.62 66.49,44.11 76.62,44.11
SERDES_2_RX3_P: length 12.7
  TOP w0.127: U1.AH25 65.65,45.4 65.65,44.49 66.35,43.78 76.62,43.78
SERDES_2_TX0_N: length 8.5
  TOP w0.127: U1.AC28 68.48,50.56 68.97,50.56 69.36,50.17 76.62,50.17
SERDES_2_TX0_P: length 9.7
  TOP w0.127: 76.62,49.84 69.22,49.84 68.83,50.23 67.81,50.23 U1.AC27
SERDES_2_TX1_N: length 7.5
  TOP w0.254: U1.AD26 v1(66.81,49.23)
  L3_SIG1 w0.127: 73.41,48.67 67.63,48.67 67.07,49.23 v1(66.81,49.23)
SERDES_2_TX1_P: length 8.7
  TOP w0.254: U1.AD25 v1(65.81,49.23)
  L3_SIG1 w0.127: v1(65.81,49.23) 66.31,48.73 67.17,48.73 67.51,48.39 73.41,48.39
SERDES_2_TX2_N: length 8.5
  TOP w0.127: 76.62,48.17 69.36,48.17 68.97,48.56 68.48,48.56 U1.AE28
SERDES_2_TX2_P: length 9.7
  TOP w0.127: U1.AE27 67.81,48.23 68.83,48.23 69.22,47.84 76.62,47.84
SERDES_2_TX3_N: length 8.5
  TOP w0.127: 76.62,46.17 69.36,46.17 68.97,46.56 68.48,46.56 U1.AG28
SERDES_2_TX3_P: length 9.7
  TOP w0.127: U1.AG27 67.81,46.23 68.83,46.23 69.22,45.84 76.62,45.84
SERDES_3_INT_REFCLK_N: length 5.7
  TOP w0.254: U1.J24 v1(64.81,65.23)
  L4_SIG2 w0.102: v1(64.81,65.23) 65.19,65.61 69.68,65.61
SERDES_3_INT_REFCLK_P: length 6.8
  TOP w0.254: U1.J23 v1(63.81,65.23)
  L4_SIG2 w0.102: 69.68,65.86 64.44,65.86 v1(63.81,65.23)
SERDES_3_RX0_N: length 14.3
  TOP w0.127: U1.A23 63.65,73.07 63.65,73.78 66.02,76.15 75.82,76.15
SERDES_3_RX0_P: length 13.8
  TOP w0.127: 75.82,75.82 66.16,75.82 63.98,73.64 63.98,73.07 U1.A24
SERDES_3_RX1_N: length 13.1
  TOP w0.254: U1.C23 v1(63.81,71.23)
  L3_SIG1 w0.127: v1(63.81,71.23) 64.15,71.57 64.15,71.77 63.74,72.18 63.74,73.08 65.52,74.86 73.28,74.86
SERDES_3_RX1_P: length 12.7
  TOP w0.254: U1.C24 v1(64.81,71.23)
  L3_SIG1 w0.127: 73.28,74.58 65.64,74.58 64.02,72.96 64.02,72.3 64.48,71.84 64.48,71.57 v1(64.81,71.23)
SERDES_3_RX2_N: length 10.7
  TOP w0.254: U1.E23 v1(63.81,69.23)
  L3_SIG1 w0.127: 73.4,69.26 67.45,69.26 66.92,68.74 64.31,68.74 v1(63.81,69.23)
SERDES_3_RX2_P: length 9.6
  TOP w0.254: U1.E24 v1(64.81,69.23)
  L3_SIG1 w0.127: v1(64.81,69.23) 65.31,69.73 67.21,69.73 67.4,69.54 73.4,69.54
SERDES_3_RX3_N: length 8.6
  TOP w0.254: U1.F25 v1(65.81,68.23)
  L3_SIG1 w0.127: 73.38,67.36 67.5,67.36 67.12,67.73 66.31,67.73 v1(65.81,68.23)
SERDES_3_RX3_P: length 7.5
  TOP w0.254: U1.F26 v1(66.81,68.23)
  L3_SIG1 w0.127: 73.38,67.64 67.68,67.64 67.09,68.23 v1(66.81,68.23)
SERDES_3_TX0_N: length 8.8
  TOP w0.254: U1.B25 v1(65.81,72.23)
  L3_SIG1 w0.127: 73.41,73.49 67.88,73.49 67.12,72.73 66.31,72.73 v1(65.81,72.23)
SERDES_3_TX0_P: length 7.7
  TOP w0.254: U1.B26 v1(66.81,72.23)
  L3_SIG1 w0.127: 73.41,73.21 68,73.21 67.02,72.23 v1(66.81,72.23)
SERDES_3_TX1_N: length 9.7
  TOP w0.127: U1.C27 67.81,71.23 68.83,71.23 69.22,71.62 76.62,71.62
SERDES_3_TX1_P: length 8.5
  TOP w0.127: 76.62,71.29 69.36,71.29 68.97,70.9 68.48,70.9 U1.C28
SERDES_3_TX2_N: length 8.8
  TOP w0.254: U1.D25 v1(65.81,70.23)
  L3_SIG1 w0.127: v1(65.81,70.23) 66.31,70.73 67.13,70.73 67.8,71.4 73.41,71.4
SERDES_3_TX2_P: length 7.7
  TOP w0.254: U1.D26 v1(66.81,70.23)
  L3_SIG1 w0.127: 73.41,71.12 67.91,71.12 67.03,70.23 v1(66.81,70.23)
SERDES_3_TX3_N: length 9.7
  TOP w0.127: 76.62,69.62 69.22,69.62 68.83,69.23 67.81,69.23 U1.E27
SERDES_3_TX3_P: length 8.5
  TOP w0.127: U1.E28 68.48,68.9 68.97,68.9 69.36,69.29 76.62,69.29
SERDES_13_EXT_REFCLK_N: length 5.7
  TOP w0.254: U1.L24 v1(64.81,63.23)
  L4_SIG2 w0.102: v1(64.81,63.23) 65.18,63.6 69.65,63.6
SERDES_13_EXT_REFCLK_P: length 6.8
  TOP w0.254: U1.L23 v1(63.81,63.23)
  L4_SIG2 w0.102: 69.65,63.86 64.44,63.86 v1(63.81,63.23)
SERDES_24_EXT_REFCLK_N: length 5.7
  TOP w0.254: U1.AA24 v1(64.81,52.23)
  L4_SIG2 w0.102: 69.62,52.6 65.18,52.6 v1(64.81,52.23)
SERDES_24_EXT_REFCLK_P: length 6.8
  TOP w0.254: U1.AA23 v1(63.81,52.23)
  L4_SIG2 w0.102: 69.62,52.86 64.44,52.86 v1(63.81,52.23)
SERDES_35_EXT_REFCLK_N: length 5.7
  TOP w0.254: U1.G24 v1(64.81,67.23)
  L4_SIG2 w0.102: 69.62,67.6 65.18,67.6 v1(64.81,67.23)
SERDES_35_EXT_REFCLK_P: length 6.8
  TOP w0.254: U1.G23 v1(63.81,67.23)
  L4_SIG2 w0.102: v1(63.81,67.23) 64.44,67.86 69.62,67.86
SERDES_VREF1: length 0.7
  TOP w0.254: U1.F22 v1(62.81,68.23)
SERDES_VREF2: length 0.7
  TOP w0.254: U1.H22 v1(62.81,66.23)

## Text on the board
BOTTOM: Layer 14 (BOTTOM)
Ref Des/Assembly Bottom: ASSEMBLY_BOTTOM
Ref Des/Silkscreen Bottom: 305-PD-1X-XXXX | MICROSEMI TECHNICAL SUPPORT | +1(800) 262-1060
TOP: Layer 1 (TOP)
Ref Des/Assembly Top: ASSEMBLY_TOP
Ref Des/Silkscreen Top: RT4G_DEVELOPMENT_KIT REV A | DVP-101-000XXX-001
FAB_DATA: 4.0 MILS | 6.5 MILS | 50 OHM | SINGLE | 3.5/8.0 MILS | DIFFERENTIAL | 5 / 8 MILS | 100 OHM | 5.1 / 4.9 MILS | 90 OHM | REV | 1 | INTIAL RELEASE | DESCRIPTION | REVISIONS | XXXXXXXX | DATE | APPROVAL | 10.  VIAS IN THIS REGION NEEDS VIA PLUGGING FROM BOTTOM SIDE. | 14.  IMPEDANCE TOLERANCE SHOULD BE +/- 5% ON L1, L12, L14. REST OF THE LAYRES CAN HAVE 10% TOLERANCE | 11.  BOARD MUST BE UL 94V-1 APPROVED. | 12.  FABRICATE BOARD PER IPC-A-600D STANDARD. | 13.  CLIP SILKSCREEN ON NO MASK AREA. | 17.  REMOVE UNUSED PADS IN ALL INNER LAYERS. | 18.  BOARD DIMENSIONS ARE IN INCHES | 15.  NO VENDOR LOGO, ART WORKS SHOULD NOT BE | 20.  THIS IS A ROHS COMPLIANT BOARD | 19.  WARP & TWIST: SHALL NOT EXCEED 0.005 INCHES PER INCH | 2.1. SELECTIVE HARD GOLD PLATING TO BE FLAT & | 16.  DEBURR ALL SHARP EDGES | 21.  EDGE FINGER- CHAMFER EDGES MUST BE FREE OF CUTTING BURRS | 5.  SILKSCREEN BOTH SIDES, WHITE. | 7.  SOLDER MASK TOP AND BOTTOM SIDES WITH | 6.  FABRICATE PER DIMENSIONS SHOWN. | PLATING IN HOLES TO BE 0.001 MIN. THICK. | 4.  HOLE SIZES ARE AFTER PLATING. | 3.  HOLES TO BE PLATED THROUGH. | 9.  APPLY THIEVING AS REQUIRED. | 8.  TOTAL BOARD THICKNESS:  62 mil+/- 6 mil | SOLDER MASK.  COLOR GREEN. | LIQUID PHOTO IMAGABLE OR DRY FILM | 14 LAYER CONSTRUCTION. | 2.  GENERAL PLATING - FLASH GOLD | NOTES: UNLESS OTHERWISE SPECIFIED | 1.  MATERIAL: FR-4. | ABOVE THE SOLDER RESIST SURFACE ON TOP AND BOTTOM | THE VIAS SHOULD BE SMOOTHENED TO BOARD SURFACE ON TOP AND BOTTOM | GOLD PLATING ON PAD SHOULD BE THE SAME LEVEL OR | FOR SELECTIVE PLATING SEE BELOW | CHANGED WITHOUT PRIOR APPROVAL FROM PACTRON | PLATED 30uIN(MINIMUM) OF Au OVER 150-200uIN OF Ni. | NOTE: DIELECTRIC GLASS STYLE SHOULD NOT BE CHANGED WITHOUT PRIOR APPROVAL FROM PACTRON. | GLASS STYLE | DIELECTRIC | SHOULD NOT BE CHANGED FROM ABOVE STATED VALUES. | FINISHED TRACE WIDTH,AIR GAP OF 100 OHM DIFFERENTIAL AND 50 OHM SIGNLE ENDED | 2116 | STACKUP - 14 LAYERS | REFER STACKUP | CONTROLLED IMPEDANCE REQUIRED
User.17: FIGURE | SIZE | 125.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 2
User.19: DATE: | FILM LAYER: | NAME: | XXXXXXXX | XXXXXXXXXXXXXXXXXXXX | REV: | A | PACTRON
User.20: FAB | PROJECT NAME | PART NUMBER | PACTRON | DATE | 3000 PATRICK HENRY DRIVE, SANTA CLARA, CA 95054. | 408-329-5500(PHONE), 408-747-1239(FAX). | XXXXXXXXXXXXXXXXXXXXXX | DVP-101-000XXX-001 | XXXXXXXX | 305-PD-15-XXXX | REV : | A
User.23: DIELECTRIC (4.00 mils) | DIELECTRIC (4.50 mils) | DIELECTRIC (3.50 mils) | DIELECTRIC (2.00 mils) | TOP (1.40 mils) | L2_GND1 (0.60 mils) | L3_SIG1 (0.60 mils) | L4_GND2 (0.60 mils) | L5_SIG2 (0.60 mils) | L6_GND3 (0.60 mils) | L7_PWR1 (1.30 mils) | L8_PWR2 (1.30 mils) | L9_GND4 (0.60 mils) | L10_SIG3 (0.60 mils) | L11_GND5 (0.60 mils) | L12_SIG4 (0.60 mils) | L13_GND6 (0.60 mils) | BOTTOM (1.40 mils) | FR-4
