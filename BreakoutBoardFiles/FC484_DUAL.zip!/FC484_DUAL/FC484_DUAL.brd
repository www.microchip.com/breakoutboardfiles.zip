# Allegro board FC484_DUAL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IO48: length 8.3
  TOP w0.254: U1.M7 v1(49.81,58.23)
  L3_SIG1 w0.102: v1(49.81,58.23) 49.42,58.62 45.36,58.62 44.76,59.23 42.61,59.23
IO49: length 7.4
  TOP w0.254: U1.L6 v1(48.81,60.23)
  L3_SIG1 w0.102: v1(48.81,60.23) 48.21,59.63 46.3,59.63 45.76,60.17 42.61,60.17
IO50: length 5.1
  TOP w0.254: U1.K4 v1(46.81,61.23)
  L3_SIG1 w0.102: v1(46.81,61.23) 46.15,61.23 45.7,61.68 42.61,61.68
IO51: length 6.2
  TOP w0.254: U1.K5 v1(47.81,61.23)
  L3_SIG1 w0.102: v1(47.81,61.23) 47.42,61.63 46.25,61.63 45.99,61.89 42.61,61.89
IO52: length 5.7
  TOP w0.127: 41.9,58.03 44.07,58.03 44.15,58.12 46.7,58.12 U1.M4
IO53: length 4.4
  TOP w0.127: U1.L3 45.93,59.35 43.98,59.35 43.9,59.43 42.06,59.43
IO54: length 6
  TOP w0.254: U1.M5 v1(47.81,58.23)
  L3_SIG1 w0.102: 42.58,58.3 47.01,58.3 47.08,58.23 v1(47.81,58.23)
IO55: length 6.3
  TOP w0.254: U1.L5 v1(47.81,60.23)
  L3_SIG1 w0.102: v1(47.81,60.23) 47.42,59.84 46.39,59.84 45.85,60.38 42.61,60.38
IO56: length 2.3
  TOP w0.127: U1.L1 42.06,59.73
IO57: length 2.3
  TOP w0.127: U1.K1 42.06,60.73
IO58: length 3.5
  TOP w0.127: U1.J2 44.93,62.12 41.95,62.12
IO59: length 4.6
  TOP w0.127: U1.J3 45.71,62.34 41.95,62.34
IO60: length 3.4
  TOP w0.127: 42.06,60.12 44.93,60.12 U1.L2
IO61: length 4.4
  TOP w0.127: 42.06,60.35 45.93,60.35 U1.K3
IO62: length 2.4
  TOP w0.127: U1.J1 41.95,61.73
IO63: length 2.4
  TOP w0.127: U1.H1 41.95,62.73
IO64: length 2.3
  TOP w0.127: U1.F1 42,64.73
IO65: length 3.5
  TOP w0.127: 42,64.43 43.9,64.43 43.98,64.35 44.93,64.35 U1.F2
IO66: length 3.6
  TOP w0.127: 41.95,63.03 43.9,63.03 43.98,63.12 44.93,63.12 U1.H2
IO67: length 3.6
  TOP w0.127: 41.95,63.25 43.81,63.25 43.9,63.35 44.93,63.35 U1.G2
IO68: length 7.5
  TOP w0.254: U1.F12 v1(55.81,65.23)
  L3_SIG1 w0.102: 55.42,71.82 55.42,65.63 v1(55.81,65.23)
IO69: length 7.6
  TOP w0.254: U1.F13 v1(56.81,65.23)
  L3_SIG1 w0.102: v1(56.81,65.23) 56.42,65.62 56.42,66.77 56.1,67.09 56.1,71.82
IO70: length 7.5
  TOP w0.254: U1.F11 v1(53.81,65.23)
  L3_SIG1 w0.102: 54.44,71.82 54.44,65.86 v1(53.81,65.23)
IO71: length 6.5
  TOP w0.254: U1.E11 v1(53.81,66.23)
  L3_SIG1 w0.102: v1(53.81,66.23) 54.2,66.62 54.2,71.82
IO72: length 7.1
  TOP w0.254: U1.K6 v1(48.81,61.23)
  L3_SIG1 w0.102: v1(48.81,61.23) 48.42,60.84 42.61,60.84
IO73: length 7.1
  TOP w0.254: U1.J6 v1(48.81,62.23)
  L3_SIG1 w0.102: 42.61,62.63 48.42,62.63 v1(48.81,62.23)
IO74: length 8.2
  TOP w0.254: U1.J7 v1(49.81,62.23)
  L3_SIG1 w0.102: 42.61,62.84 48.89,62.84 49.5,62.23 v1(49.81,62.23)
IO75: length 9.2
  TOP w0.254: U1.H7 v1(49.81,63.23)
  L3_SIG1 w0.102: v1(49.81,63.23) 49.2,63.84 48.65,63.84 48.42,64.07 48.42,64.58 48.16,64.84 47.65,64.84 47.37,65.12 47.37,65.24 46.99,65.62 42.7,65.62
IO76: length 6.5
  TOP w0.254: U1.E13 v1(56.81,66.23)
  L3_SIG1 w0.102: 56.42,71.82 56.42,67.07 56.81,66.68 v1(56.81,66.23)
IO77: length 5.7
  TOP w0.254: U1.D13 v1(56.81,67.23)
  L3_SIG1 w0.102: v1(56.81,67.23) 56.81,67.65 57.2,68.04 57.2,68.98 56.69,69.5 56.69,71.82
IO78: length 9.2
  TOP w0.254: U1.K8 v1(50.81,61.23)
  L3_SIG1 w0.102: v1(50.81,61.23) 50.21,60.63 42.61,60.63
IO79: length 10.7
  TOP w0.254: U1.J8 v1(50.81,62.23)
  L3_SIG1 w0.102: v1(50.81,62.23) 50.5,62.23 50.03,62.7 49.6,62.7 49.21,63.08 49.21,63.44 49.02,63.63 48.56,63.63 48.21,63.98 48.21,64.49 48.07,64.63 47.56,64.63 47.35,64.84 46.62,64.84 46.23,65.23 42.61,65.23
IO80: length 4.9
  TOP w0.254: U1.J4 v1(46.81,62.23)
  L3_SIG1 w0.102: v1(46.81,62.23) 46.73,62.32 42.61,62.32
IO81: length 5.2
  TOP w0.254: U1.H4 v1(46.81,63.23)
  L3_SIG1 w0.102: 42.61,63.28 44.65,63.28 44.99,63.63 46.02,63.63 46.41,63.23 v1(46.81,63.23)
IO82: length 6.3
  TOP w0.254: U1.H5 v1(47.81,63.23)
  L3_SIG1 w0.102: 42.61,64.17 45.89,64.17 46.44,63.62 46.65,63.62 46.65,63.62 46.98,63.62 46.98,63.62 47.42,63.62 v1(47.81,63.23)
IO83: length 7.4
  TOP w0.254: U1.H6 v1(48.81,63.23)
  L3_SIG1 w0.102: 42.61,64.39 45.98,64.39 46.53,63.84 47.76,63.84 48.37,63.23 v1(48.81,63.23)
IO84: length 10.3
  TOP w0.254: U1.K9 v1(51.81,61.23)
  L3_SIG1 w0.102: v1(51.81,61.23) 51.2,61.84 46.52,61.84 46.25,62.1 42.61,62.1
IO85: length 12.4
  TOP w0.254: U1.J9 v1(51.81,62.23)
  L3_SIG1 w0.102: 42.66,66.78 45.06,66.78 45.66,66.19 47.1,66.19 47.45,65.84 47.84,65.84 48.3,65.39 48.3,65 48.58,64.72 49.03,64.72 49.42,64.32 49.42,64.07 49.65,63.84 50.08,63.84 50.3,63.62 50.3,63.15 50.81,62.64 51.4,62.64 v1(51.81,62.23)
IO86: length 2.3
  TOP w0.127: U1.D1 42,66.73
IO87: length 2.3
  TOP w0.127: U1.E1 42,65.73
IO88: length 3.6
  TOP w0.127: U1.C2 44.71,68.34 41.98,68.34
IO89: length 3.5
  TOP w0.127: 42,67.12 44.47,67.12 44.86,66.73 U1.D2
IO90: length 2.3
  TOP w0.127: U1.B1 42,68.73
IO91: length 2.3
  TOP w0.127: U1.C1 42,67.73
IO92: length 2.2
  TOP w0.127: U1.A3 46.31,71.9
IO93: length 2.2
  TOP w0.127: U1.A2 45.31,71.9
IO94: length 5
  TOP w0.127: U1.D3 45.71,67.34 44.99,67.34 44.82,67.52 44.82,67.77 44.47,68.12 42.02,68.12
IO95: length 4.5
  TOP w0.127: U1.E3 45.93,65.35 42,65.35
IO96: length 3
  TOP w0.127: 45.71,71.43 45.71,69.34 U1.B3
IO97: length 3.4
  TOP w0.127: U1.B2 44.79,69.26 44.79,71.9
IO98: length 6.6
  TOP w0.254: U1.E14 v1(57.81,66.23)
  L3_SIG1 w0.102: 57.81,71.82 57.81,70.13 57.63,69.96 57.63,67.76 57.42,67.55 57.42,66.62 v1(57.81,66.23)
IO99: length 5.4
  TOP w0.254: U1.D14 v1(57.81,67.23)
  L3_SIG1 w0.102: v1(57.81,67.23) 57.92,67.34 57.92,69.87 58.09,70.04 58.09,71.82
IO100: length 6.3
  TOP w0.254: U1.E5 v1(47.81,66.23)
  L3_SIG1 w0.102: v1(47.81,66.23) 47.42,66.23 47.16,66.49 45.8,66.49 45.17,67.12 42.61,67.12
IO101: length 6.1
  TOP w0.254: U1.F5 v1(47.81,65.23)
  L3_SIG1 w0.102: v1(47.81,65.23) 47.7,65.23 47.09,65.84 42.71,65.84
IO102: length 4.5
  TOP w0.127: 46.6,71.9 46.6,69.99 46.7,69.89 46.7,69.41 46.93,69.18 46.93,68.12 U1.C4
IO103: length 5.4
  TOP w0.127: U1.D4 46.71,67.34 46.71,69.09 46.55,69.25 46.25,69.25 45.93,69.57 45.93,71.37
IO104: length 6.2
  TOP w0.127: 41.98,67.34 44.57,67.34 44.79,67.12 45.47,67.12 45.7,66.89 45.7,66.63 46.21,66.12 46.93,66.12 U1.E4
IO105: length 4.5
  TOP w0.127: U1.F3 45.92,65.13 42,65.13
IO106: length 2.2
  TOP w0.127: U1.A5 48.31,71.9
IO107: length 3.4
  TOP w0.127: U1.B4 47.31,69.19 46.92,69.58 46.92,69.98 46.82,70.08 46.82,71.9
IO108: length 5.5
  TOP w0.254: U1.D6 v1(48.81,67.23)
  L3_SIG1 w0.102: v1(48.81,67.23) 48.81,68.58 48.42,68.97 48.42,71.82
IO109: length 6.7
  TOP w0.254: U1.E6 v1(48.81,66.23)
  L3_SIG1 w0.102: 47.84,71.82 47.84,67.97 48.2,67.6 48.2,66.99 48.81,66.38 v1(48.81,66.23)
IO110: length 3.4
  TOP w0.127: U1.B5 47.93,69.12 47.93,70.06 48.01,70.15 48.01,71.9
IO111: length 4.5
  TOP w0.127: 47.79,71.9 47.79,70.24 47.71,70.15 47.71,68.34 U1.C5
IO112: length 4.4
  TOP w0.127: U1.C15 58.7,68.12 58.7,72.02
IO113: length 4.5
  TOP w0.127: U1.C14 57.71,68.13 57.71,69.02 57.71,69.03 57.71,70.15 57.79,70.24 57.79,72.02
IO114: length 3.4
  TOP w0.127: U1.B17 60.7,69.12 60.7,72.02
IO115: length 2.3
  TOP w0.127: U1.A17 60.31,72.02
IO116: length 3.5
  TOP w0.127: U1.B15 57.93,69.12 57.93,70.06 58.01,70.15 58.01,72.02
IO117: length 3.5
  TOP w0.127: U1.B14 56.93,69.12 56.93,70.15 56.83,70.24 56.83,72.02
IO118: length 4.5
  TOP w0.127: 60.92,72.02 60.92,68.34 U1.C17
IO119: length 4.4
  TOP w0.127: U1.C16 58.93,68.12 58.93,72.02
IO120: length 2.3
  TOP w0.127: U1.A16 59.31,72.02
IO121: length 2.3
  TOP w0.127: U1.A15 58.31,72.02
IO122: length 5.5
  TOP w0.254: U1.D8 v1(50.81,67.23)
  L3_SIG1 w0.102: v1(50.81,67.23) 50.81,67.68 50.42,68.07 50.42,71.82
IO123: length 6.5
  TOP w0.254: U1.E8 v1(50.81,66.23)
  L3_SIG1 w0.102: 50.2,71.82 50.2,67.81 50.42,67.6 50.42,67 50.81,66.6 v1(50.81,66.23)
IO124: length 10.5
  TOP w0.254: U1.H13 v1(56.81,63.23)
  L3_SIG1 w0.102: 54.95,71.82 54.95,64.32 55.52,63.76 56.29,63.76 v1(56.81,63.23)
IO125: length 8.8
  TOP w0.254: U1.G14 v1(57.81,64.23)
  L3_SIG1 w0.102: v1(57.81,64.23) 57.21,64.84 57.21,67.69 57.42,67.9 57.42,69.07 56.9,69.59 56.9,71.82
IO126: length 8.6
  TOP w0.254: U1.G15 v1(58.81,64.23)
  L3_SIG1 w0.102: 58.36,71.82 58.36,69.91 58.21,69.76 58.21,64.84 v1(58.81,64.23)
IO127: length 9.6
  TOP w0.254: U1.H15 v1(58.81,63.23)
  L3_SIG1 w0.102: v1(58.81,63.23) 59.42,63.84 59.42,68.6 59.21,68.81 59.21,71.82
IO128: length 5.3
  TOP w0.254: U1.D17 v1(60.81,67.23)
  L3_SIG1 w0.102: v1(60.81,67.23) 60.81,71.82
IO129: length 5.5
  TOP w0.254: U1.D16 v1(59.81,67.23)
  L3_SIG1 w0.102: v1(59.81,67.23) 59.81,68.51 59.42,68.9 59.42,71.82
IO130: length 6.5
  TOP w0.254: U1.E16 v1(59.81,66.23)
  L3_SIG1 w0.102: v1(59.81,66.23) 60.2,66.62 60.2,68.53 60.39,68.71 60.39,71.82
IO131: length 6.5
  TOP w0.254: U1.E15 v1(58.81,66.23)
  L3_SIG1 w0.102: 58.63,71.82 58.63,69.88 58.42,69.67 58.42,66.62 v1(58.81,66.23)
IO132: length 7.5
  TOP w0.254: U1.F17 v1(60.81,65.23)
  L3_SIG1 w0.102: v1(60.81,65.23) 61.2,65.62 61.2,71.82
IO133: length 8.5
  TOP w0.254: U1.G17 v1(60.81,64.23)
  L3_SIG1 w0.102: v1(60.81,64.23) 61.42,64.84 61.42,71.82
IO134: length 7.6
  TOP w0.254: U1.F16 v1(59.81,65.23)
  L3_SIG1 w0.102: v1(59.81,65.23) 60.42,65.84 60.42,67.91 60.6,68.09 60.6,71.82
IO135: length 7.5
  TOP w0.254: U1.F15 v1(58.81,65.23)
  L3_SIG1 w0.102: v1(58.81,65.23) 59.21,65.63 59.21,68.51 59,68.72 59,71.82
IO136: length 2.2
  TOP w0.127: U1.A7 50.31,71.88
IO137: length 2.2
  TOP w0.127: U1.A6 49.31,71.88
IO138: length 5.3
  TOP w0.254: U1.D9 v1(51.81,67.23)
  L3_SIG1 w0.102: v1(51.81,67.23) 51.81,71.82
IO139: length 6.5
  TOP w0.254: U1.E9 v1(51.81,66.23)
  L3_SIG1 w0.102: v1(51.81,66.23) 51.42,66.62 51.42,71.82
IO140: length 2.2
  TOP w0.127: U1.A8 51.31,71.88
IO141: length 3.3
  TOP w0.127: U1.B8 50.93,69.12 50.93,71.88
IO142: length 3.5
  TOP w0.127: 56.61,72.02 56.61,70.15 56.7,70.06 56.7,69.12 U1.B13
IO143: length 3.5
  TOP w0.127: 55.7,72.02 55.7,69.11 55.33,68.73 U1.B12
IO144: length 4.5
  TOP w0.127: 52.79,71.89 52.79,70.24 52.7,70.15 52.7,68.35 U1.C10
IO145: length 4.5
  TOP w0.127: U1.C9 51.7,68.35 51.7,69.89 51.57,70.02 51.57,71.88
IO146: length 3.3
  TOP w0.127: U1.B10 52.92,69.13 52.92,70.05 53.01,70.15 53.01,71.86
IO147: length 3.4
  TOP w0.127: U1.B9 51.92,69.13 51.92,69.98 51.83,70.07 51.83,71.88
IO148: length 4.4
  TOP w0.127: U1.C12 54.93,68.12 54.93,72.02
IO149: length 4.4
  TOP w0.127: 54.71,72.02 54.71,68.13 U1.C11
IO150: length 8.6
  TOP w0.254: U1.T11 v1(53.81,54.23)
  L3_SIG1 w0.102: v1(53.81,54.23) 53.87,54.23 54.34,53.76 54.34,49.25 54.84,48.74 54.84,46.82
IO151: length 9.9
  TOP w0.254: U1.R12 v1(55.81,55.23)
  L3_SIG1 w0.102: v1(55.81,55.23) 54.59,54.01 54.59,49.36 55.14,48.82 55.14,46.82
IO152: length 7.8
  TOP w0.254: U1.U14 v1(57.81,53.23)
  L3_SIG1 w0.102: v1(57.81,53.23) 57.42,52.84 57.42,50.58 58.23,49.77 58.23,49.05 57.78,48.6 57.78,46.8
IO153: length 6.7
  TOP w0.254: U1.V14 v1(57.81,52.23)
  L3_SIG1 w0.102: v1(57.81,52.23) 58.2,51.84 58.2,50.66 58.71,50.15 58.71,48.76 58.29,48.33 58.29,46.82
IO154: length 4.3
  TOP w0.127: 52.7,46.61 52.7,50.35 U1.Y9
IO155: length 5.3
  TOP w0.254: U1.W9 v1(51.81,51.23)
  L3_SIG1 w0.102: v1(51.81,51.23) 51.81,49.97 52.2,49.58 52.2,46.79
IO156: length 6.4
  TOP w0.254: U1.V10 v1(52.81,52.23)
  L3_SIG1 w0.102: 52.9,46.79 52.9,49.39 53.2,49.7 53.2,51.39 52.81,51.79 v1(52.81,52.23)
IO157: length 6.3
  TOP w0.254: U1.V9 v1(51.81,52.23)
  L3_SIG1 w0.102: v1(51.81,52.23) 51.42,51.84 51.42,46.79
IO158: length 9.7
  TOP w0.254: U1.R10 v1(52.81,55.23)
  L3_SIG1 w0.102: 53.47,46.79 53.47,49.15 53.78,49.46 53.78,51.67 53.42,52.02 53.42,54.62 v1(52.81,55.23)
IO159: length 10.8
  TOP w0.254: U1.R9 v1(51.81,55.23)
  L3_SIG1 w0.102: v1(51.81,55.23) 51.42,54.84 50.72,54.84 50.42,54.54 50.42,53.82 50.21,53.61 50.21,52.91 49.92,52.62 49.65,52.62 49.42,52.39 49.42,51.74 49.21,51.53 49.21,50.13 48.3,49.21 48.3,47.14
IO160: length 7.4
  TOP w0.254: U1.U10 v1(52.81,53.23)
  L3_SIG1 w0.102: 52.68,46.79 52.68,49.7 52.42,49.96 52.42,52.39 52.81,52.79 v1(52.81,53.23)
IO161: length 8.6
  TOP w0.254: U1.T10 v1(52.81,54.23)
  L3_SIG1 w0.102: v1(52.81,54.23) 53.21,53.84 53.21,51.83 53.51,51.53 53.51,49.57 53.2,49.26 53.2,46.79
IO162: length 7.4
  TOP w0.254: U1.U9 v1(51.81,53.23)
  L3_SIG1 w0.102: 51.21,46.79 51.21,52.63 v1(51.81,53.23)
IO163: length 7.4
  TOP w0.254: U1.U8 v1(50.81,53.23)
  L3_SIG1 w0.102: 50.66,46.79 50.66,50.65 50.42,50.89 50.42,52.39 50.65,52.62 50.81,52.79 v1(50.81,53.23)
IO164: length 8.5
  TOP w0.254: U1.T8 v1(50.81,54.23)
  L3_SIG1 w0.102: v1(50.81,54.23) 50.81,53.87 50.42,53.48 50.42,52.72 50.2,52.51 50.2,50.71 50.44,50.48 50.44,46.79
IO165: length 10
  TOP w0.254: U1.T7 v1(49.81,54.23)
  L3_SIG1 w0.102: 42.37,51.26 46.74,51.26 47.32,51.84 47.98,51.84 48.2,52.07 48.2,52.77 48.42,52.98 48.42,53.39 48.65,53.62 49.2,53.62 v1(49.81,54.23)
IO166: length 4.5
  TOP w0.127: U1.Y8 50.71,50.13 50.71,46.5
IO167: length 3.4
  TOP w0.127: 50.93,46.5 50.93,49.35 U1.AA8
IO168: length 2.2
  TOP w0.127: U1.AB7 50.31,46.5
IO169: length 3.4
  TOP w0.127: 50.01,46.5 50.01,48.32 49.93,48.4 49.93,49.35 U1.AA7
IO170: length 5.2
  TOP w0.254: U1.W8 v1(50.81,51.23)
  L3_SIG1 w0.102: 50.94,46.79 50.94,50.73 50.81,50.86 v1(50.81,51.23)
IO171: length 5.3
  TOP w0.254: U1.W7 v1(49.81,51.23)
  L3_SIG1 w0.102: v1(49.81,51.23) 49.81,50.8 50.2,50.41 50.2,46.79
IO172: length 2.2
  TOP w0.127: U1.AB5 48.31,46.5
IO173: length 3.4
  TOP w0.127: U1.AA5 48.7,49.35 48.7,48.57 48.57,48.44 48.57,46.5
IO174: length 3.4
  TOP w0.127: 49.79,46.5 49.79,48.22 49.7,48.32 49.7,49.35 U1.AA6
IO175: length 4.4
  TOP w0.127: 48.83,46.5 48.83,48.39 48.92,48.48 48.92,50.34 U1.Y6
IO176: length 6.3
  TOP w0.254: U1.V7 v1(49.81,52.23)
  L3_SIG1 w0.102: v1(49.81,52.23) 49.81,51.83 49.42,51.43 49.42,49.86 48.59,49.03 48.59,47.14
IO177: length 7.8
  TOP w0.254: U1.U7 v1(49.81,53.23)
  L3_SIG1 w0.102: v1(49.81,53.23) 49.2,52.62 49.2,51.89 49,51.69 48.73,51.69 48.42,51.38 48.42,50.64 47.77,49.99 47.77,47.16
IO178: length 2.2
  TOP w0.127: U1.AB4 47.31,46.5
IO179: length 2.2
  TOP w0.127: U1.AB3 46.31,46.51
IO180: length 5.1
  TOP w0.254: U1.W6 v1(48.81,51.23)
  L3_SIG1 w0.102: v1(48.81,51.23) 48.81,50.33 47.98,49.5 47.98,47.14
IO181: length 8.6
  TOP w0.254: U1.V6 v1(48.81,52.23)
  L3_SIG1 w0.102: v1(48.81,52.23) 48.81,52.08 48.2,51.47 48.2,50.88 47.61,50.29 46.85,50.29 46.25,49.69 42.44,49.69
IO182: length 2.2
  TOP w0.127: U1.AB2 45.31,46.51
IO183: length 3.6
  TOP w0.127: U1.AA2 44.93,49.35 41.9,49.35
IO184: length 4.4
  TOP w0.127: U1.Y5 47.92,50.34 47.92,46.5
IO185: length 4.4
  TOP w0.127: U1.Y4 47.7,50.35 47.7,46.5
IO186: length 3.4
  TOP w0.127: 45.93,46.51 45.93,49.18 46.31,49.56 U1.AA3
IO187: length 4.5
  TOP w0.127: U1.Y3 45.92,50.34 45.92,49.48 45.71,49.27 45.71,46.51
IO188: length 7.3
  TOP w0.127: 41.73,49.12 45.25,49.12 45.7,49.57 45.7,50.43 45.9,50.63 45.9,50.87 46.15,51.12 46.7,51.12 U1.W4
IO189: length 6.4
  TOP w0.254: U1.V5 v1(47.81,52.23)
  L3_SIG1 w0.102: v1(47.81,52.23) 47.27,52.23 46.53,51.49 42.47,51.49
IO190: length 2.4
  TOP w0.127: U1.AA1 41.9,49.73
IO191: length 2.4
  TOP w0.127: U1.Y1 41.9,50.73
IO192: length 4.6
  TOP w0.127: U1.W3 45.86,51.73 45.47,51.35 41.9,51.35
IO193: length 6.4
  TOP w0.127: U1.V4 46.83,52.25 46.83,51.71 46.47,51.34 45.78,51.34 45.56,51.13 41.9,51.13
IO194: length 2.4
  TOP w0.127: U1.W1 41.9,51.73
IO195: length 2.4
  TOP w0.127: U1.V1 41.9,52.73
IO196: length 3.6
  TOP w0.127: U1.W2 44.93,52.12 41.9,52.12
IO197: length 3.6
  TOP w0.127: 41.9,52.34 44.93,52.34 45.31,52.73 U1.V2
IO198: length 3.6
  TOP w0.127: 41.9,53.25 43.97,53.25 44.06,53.34 44.92,53.34 U1.U2
IO199: length 4.7
  TOP w0.127: 41.9,53 44.03,53 44.15,53.12 45.7,53.12 U1.U3
IO200: length 4.9
  TOP w0.254: U1.U4 v1(46.81,53.23)
  L3_SIG1 w0.102: v1(46.81,53.23) 42.58,53.23
IO201: length 6
  TOP w0.254: U1.U5 v1(47.81,53.23)
  L3_SIG1 w0.102: v1(47.81,53.23) 47.67,53.23 47.06,52.63 42.78,52.63
IO202: length 7.4
  TOP w0.254: U1.U17 v1(60.81,53.23)
  L3_SIG1 w0.102: 61.42,46.82 61.42,52.63 v1(60.81,53.23)
IO203: length 8.5
  TOP w0.254: U1.T17 v1(60.81,54.23)
  L3_SIG1 w0.102: 60.61,46.82 60.61,48.99 60.21,49.4 60.21,51.02 60.42,51.23 60.42,53.84 v1(60.81,54.23)
IO204: length 5.8
  TOP w0.127: U1.W16 59.7,51.35 59.7,50.66 59.93,50.43 59.93,49.47 60.2,49.2 60.43,49.2 60.7,48.93 60.7,46.61
IO205: length 6.3
  TOP w0.254: U1.V16 v1(59.81,52.23)
  L3_SIG1 w0.102: 60.11,46.82 60.11,48.79 59.71,49.19 59.71,51.24 59.81,51.34 v1(59.81,52.23)
IO206: length 6.3
  TOP w0.254: U1.V17 v1(60.81,52.23)
  L3_SIG1 w0.102: v1(60.81,52.23) 61.2,51.84 61.2,46.82
IO207: length 5.5
  TOP w0.254: U1.W17 v1(60.81,51.23)
  L3_SIG1 w0.102: v1(60.81,51.23) 60.42,50.84 60.42,49.48 60.83,49.08 60.83,46.82
IO208: length 3.4
  TOP w0.127: 60.93,46.61 60.93,49.11 60.31,49.72 U1.AA17
IO209: length 2.1
  TOP w0.127: U1.AB17 60.31,46.61
IO210: length 4.4
  TOP w0.127: 60.09,46.61 60.09,48.24 59.92,48.41 59.92,49.11 59.71,49.32 59.71,50.34 U1.Y16
IO211: length 3.4
  TOP w0.127: U1.AA16 59.31,49.28 59.7,48.89 59.7,48.32 59.87,48.15 59.87,46.61
IO212: length 9.9
  TOP w0.254: U1.R16 v1(59.81,55.23)
  L3_SIG1 w0.102: 65.79,59.08 60.91,59.08 60.33,58.51 60.33,55.75 v1(59.81,55.23)
IO213: length 8.5
  TOP w0.254: U1.T16 v1(59.81,54.23)
  L3_SIG1 w0.102: v1(59.81,54.23) 60.2,53.84 60.2,51.32 59.99,51.1 59.99,49.31 60.4,48.9 60.4,46.82
IO214: length 3.3
  TOP w0.127: U1.AA15 58.7,49.35 58.7,48.57 58.56,48.44 58.56,46.61
IO215: length 4.4
  TOP w0.127: 58.83,46.61 58.83,48.22 58.93,48.32 58.93,50.12 U1.Y15
IO216: length 4.3
  TOP w0.127: U1.Y14 56.93,50.35 56.93,46.61
IO217: length 5.6
  TOP w0.254: U1.W14 v1(57.81,51.23)
  L3_SIG1 w0.102: 58.07,46.82 58.07,48.48 58.5,48.9 58.5,49.93 57.81,50.61 v1(57.81,51.23)
IO218: length 2.1
  TOP w0.127: U1.AB15 58.31,46.61
IO219: length 2.1
  TOP w0.127: U1.AB14 57.31,46.61
IO220: length 2.1
  TOP w0.127: U1.AB12 55.31,46.61
IO221: length 3.3
  TOP w0.127: U1.AA12 55.7,49.35 55.7,46.61
IO222: length 2.1
  TOP w0.127: U1.AB13 56.31,46.61
IO223: length 3.3
  TOP w0.127: 55.93,46.61 55.93,49.35 U1.AA13
IO224: length 4.3
  TOP w0.127: U1.Y13 56.71,50.34 56.71,46.61
IO225: length 5.3
  TOP w0.254: U1.W13 v1(56.81,51.23)
  L3_SIG1 w0.102: v1(56.81,51.23) 56.81,51.01 56.98,50.84 56.98,50.26 57.19,50.05 57.19,46.75
IO226: length 2.1
  TOP w0.127: U1.AB10 53.31,46.61
IO227: length 3.3
  TOP w0.127: 53.61,46.61 53.61,48.32 53.7,48.4 53.7,49.35 U1.AA10
IO228: length 3.3
  TOP w0.127: 54.79,46.61 54.79,48.22 54.7,48.32 54.7,49.35 U1.AA11
IO229: length 4.4
  TOP w0.127: 55.01,46.61 55.01,48.32 54.93,48.4 54.93,50.12 U1.Y11
IO230: length 5.3
  TOP w0.254: U1.W12 v1(55.81,51.23)
  L3_SIG1 w0.102: 56.27,46.86 56.27,50.33 55.81,50.79 v1(55.81,51.23)
IO231: length 6.5
  TOP w0.254: U1.V12 v1(55.81,52.23)
  L3_SIG1 w0.102: 55.89,46.82 55.89,49.37 55.35,49.91 55.35,51.77 v1(55.81,52.23)
IO232: length 2.1
  TOP w0.127: U1.AB9 52.31,46.61
IO233: length 2.2
  TOP w0.127: U1.AB8 51.31,46.5
IO234: length 4.3
  TOP w0.127: U1.Y10 52.93,50.35 52.93,46.61
IO235: length 5.3
  TOP w0.127: 53.83,46.61 53.83,48.22 53.92,48.31 53.92,51.34 U1.W11
IO236: length 6.4
  TOP w0.254: U1.V11 v1(53.81,52.23)
  L3_SIG1 w0.102: 53.8,46.79 53.8,48.82 54.09,49.11 54.09,51.96 v1(53.81,52.23)
IO237: length 7.6
  TOP w0.254: U1.U12 v1(55.81,53.23)
  L3_SIG1 w0.102: v1(55.81,53.23) 55.14,52.56 55.14,49.73 55.66,49.2 55.66,46.82
IO238: length 10.8
  TOP w0.254: U1.R15 v1(58.81,55.23)
  L3_SIG1 w0.102: 65.59,59.35 60.14,59.35 59.33,58.54 59.33,55.75 v1(58.81,55.23)
IO239: length 8.6
  TOP w0.254: U1.T15 v1(58.81,54.23)
  L3_SIG1 w0.102: v1(58.81,54.23) 59.42,53.63 59.42,48.95 59.81,48.56 59.81,46.79
IO240: length 7.5
  TOP w0.254: U1.U13 v1(56.81,53.23)
  L3_SIG1 w0.102: 57.4,46.68 57.4,50.21 57.2,50.4 57.2,52.84 v1(56.81,53.23)
IO241: length 8.4
  TOP w0.254: U1.T13 v1(56.81,54.23)
  L3_SIG1 w0.102: v1(56.81,54.23) 56.42,53.84 56.42,51.02 56.71,50.73 56.71,46.82
IO242: length 7.7
  TOP w0.254: U1.U15 v1(58.81,53.23)
  L3_SIG1 w0.102: 58.5,46.82 58.5,48.24 58.93,48.67 58.93,50.35 58.42,50.86 58.42,52.84 v1(58.81,53.23)
IO243: length 6.5
  TOP w0.254: U1.V15 v1(58.81,52.23)
  L3_SIG1 w0.102: v1(58.81,52.23) 59.2,51.84 59.2,48.58 58.8,48.17 58.8,46.82
IO244: length 8.8
  TOP w0.254: U1.T12 v1(55.81,54.23)
  L3_SIG1 w0.102: 55.43,46.82 55.43,48.95 54.86,49.52 54.86,53.28 v1(55.81,54.23)
IO245: length 9.5
  TOP w0.254: U1.R13 v1(56.81,55.23)
  L3_SIG1 w0.102: 56.49,46.82 56.49,50.59 56.2,50.87 56.2,54.62 v1(56.81,55.23)
IO246: length 8
  TOP w0.254: U1.F8 v1(50.81,65.23)
  L3_SIG1 w0.102: 50.81,65.25 v1(50.81,65.23) 50.2,65.84 50.2,66.46 49.89,66.77 49.63,66.77 49.42,66.98 49.42,71.83
IO247: length 9.9
  TOP w0.254: U1.G8 v1(50.81,64.23)
  L3_SIG1 w0.102: v1(50.81,64.23) 50.32,64.73 49.73,64.73 49.42,65.04 49.42,65.71 49.21,65.92 49.21,66.43 48.8,66.84 48.65,66.84 48.42,67.07 48.42,68.32 48.05,68.69 48.05,71.83
IO248: length 8.2
  TOP w0.254: U1.F6 v1(48.81,65.23)
  L3_SIG1 w0.102: 42.61,67.49 45.22,67.49 45.9,66.81 47.17,66.81 47.35,66.63 47.96,66.63 48.2,66.38 48.2,65.84 v1(48.81,65.23)
IO249: length 7.6
  TOP w0.254: U1.F7 v1(49.81,65.23)
  L3_SIG1 w0.102: v1(49.81,65.23) 49.81,65.66 49.42,66.05 49.42,66.58 49.2,66.8 49.2,71.86
IO250: length 9.9
  TOP w0.254: U1.G7 v1(49.81,64.23)
  L3_SIG1 w0.102: v1(49.81,64.23) 49.2,64.84 49.2,65.46 48.93,65.73 48.67,65.73 48.42,65.97 48.42,66.47 48.05,66.84 47.5,66.84 46.71,67.63 46.71,71.66
IO251: length 9.7
  TOP w0.254: U1.H11 v1(53.81,63.23)
  L3_SIG1 w0.102: v1(53.81,63.23) 54.73,64.15 54.73,71.82
IO252: length 8.5
  TOP w0.254: U1.G9 v1(51.81,64.23)
  L3_SIG1 w0.102: 51.21,71.82 51.21,66.38 51.42,66.17 51.42,64.63 v1(51.81,64.23)
IO253: length 9.9
  TOP w0.254: U1.H10 v1(52.81,63.23)
  L3_SIG1 w0.102: v1(52.81,63.23) 53.42,63.84 53.42,67.8 53.02,68.2 53.02,69.41 53.56,69.95 53.56,71.82
IO254: length 4.5
  TOP w0.127: 42,64.21 43.81,64.21 43.9,64.12 45.93,64.12 U1.G3
IO255: length 8.8
  TOP w0.254: U1.G10 v1(52.81,64.23)
  L3_SIG1 w0.102: 53.35,71.82 53.35,70.04 52.81,69.5 52.81,68.11 53.21,67.71 53.21,64.63 v1(52.81,64.23)
IO256: length 6.2
  TOP w0.254: U1.G5 v1(47.81,64.23)
  L3_SIG1 w0.102: v1(47.81,64.23) 47.66,64.23 47.26,64.63 46.53,64.63 46.24,64.92 42.61,64.92
IO257: length 5.1
  TOP w0.254: U1.G4 v1(46.81,64.23)
  L3_SIG1 w0.102: 42.61,64.65 46.16,64.65 46.57,64.23 v1(46.81,64.23)
SERDES_0_INT_REFCLK_N: length 4.6
  TOP w0.254: U1.R20 v1(63.81,55.23)
  BOTTOM w0.127: v1(63.81,55.23) 63.98,55.07 64.2,55.07 64.82,54.46 67.4,54.46
SERDES_0_INT_REFCLK_P: length 5.8
  TOP w0.254: U1.R19 v1(62.81,55.23)
  BOTTOM w0.127: v1(62.81,55.23) 63.31,54.74 64.07,54.74 64.68,54.13 67.4,54.13
SERDES_0_RX0_N: length 5.1
  TOP w0.127: U1.M21 64.81,58.23 69.17,58.23
SERDES_0_RX0_P: length 3.9
  TOP w0.127: 69.17,58.56 65.48,58.56 U1.M22
SERDES_0_RX1_N: length 5.1
  TOP w0.127: U1.T21 64.81,54.23 69.17,54.23
SERDES_0_RX1_P: length 3.9
  TOP w0.127: 69.17,54.56 65.48,54.56 U1.T22
SERDES_0_RX2_N: length 5.8
  TOP w0.254: U1.W19 v1(62.81,51.23)
  BOTTOM w0.127: v1(62.81,51.23) 63.31,50.74 64.07,50.74 64.68,50.13 67.4,50.13
SERDES_0_RX2_P: length 4.6
  TOP w0.254: U1.W20 v1(63.81,51.23)
  BOTTOM w0.127: v1(63.81,51.23) 63.98,51.07 64.2,51.07 64.82,50.46 67.4,50.46
SERDES_0_RX3_N: length 5.8
  TOP w0.254: U1.AA19 v1(62.81,49.23)
  BOTTOM w0.127: 67.4,48.13 64.68,48.13 64.07,48.74 63.31,48.74 v1(62.81,49.23)
SERDES_0_RX3_P: length 4.6
  TOP w0.254: U1.AA20 v1(63.81,49.23)
  BOTTOM w0.127: 67.4,48.46 64.82,48.46 64.2,49.07 63.98,49.07 v1(63.81,49.23)
SERDES_0_TX0_N: length 5.1
  TOP w0.127: U1.P21 64.81,56.23 69.17,56.23
SERDES_0_TX0_P: length 3.9
  TOP w0.127: U1.P22 65.48,56.56 69.17,56.56
SERDES_0_TX1_N: length 5.1
  TOP w0.127: U1.V21 64.81,52.23 69.17,52.23
SERDES_0_TX1_P: length 3.9
  TOP w0.127: 69.17,52.56 65.48,52.56 U1.V22
SERDES_0_TX2_N: length 5.1
  TOP w0.127: U1.Y21 64.81,50.23 69.17,50.23
SERDES_0_TX2_P: length 3.9
  TOP w0.127: 69.17,50.56 65.48,50.56 U1.Y22
SERDES_0_TX3_N: length 6.2
  TOP w0.127: U1.AB21 64.65,48.4 64.65,47.73 65.21,47.17 69.44,47.17
SERDES_0_TX3_P: length 5.6
  TOP w0.127: 69.44,47.5 65.35,47.5 64.98,47.87 64.98,48.4 U1.AB22
SERDES_0N_EXT_REFCLK_N: length 4.6
  TOP w0.254: U1.U20 v1(63.81,53.23)
  BOTTOM w0.127: v1(63.81,53.23) 63.98,53.07 64.2,53.07 64.82,52.46 67.4,52.46
SERDES_0N_EXT_REFCLK_P: length 5.8
  TOP w0.254: U1.U19 v1(62.81,53.23)
  BOTTOM w0.127: 67.4,52.13 64.68,52.13 64.07,52.74 63.31,52.74 v1(62.81,53.23)
SERDES_0S_EXT_REFCLK_N: length 4.6
  TOP w0.254: U1.N20 v1(63.81,57.23)
  BOTTOM w0.127: v1(63.81,57.23) 63.98,57.07 64.2,57.07 64.82,56.46 67.4,56.46
SERDES_0S_EXT_REFCLK_P: length 5.8
  TOP w0.254: U1.N19 v1(62.81,57.23)
  BOTTOM w0.127: 67.4,56.13 64.68,56.13 64.07,56.74 63.31,56.74 v1(62.81,57.23)
SERDES_01_EXT_REFCLK_N: length 4.6
  TOP w0.254: U1.J20 v1(63.81,62.23)
  BOTTOM w0.127: 67.4,61.46 64.82,61.46 64.2,62.07 63.98,62.07 v1(63.81,62.23)
SERDES_01_EXT_REFCLK_P: length 5.8
  TOP w0.254: U1.J19 v1(62.81,62.23)
  BOTTOM w0.127: 67.4,61.13 64.68,61.13 64.07,61.74 63.31,61.74 v1(62.81,62.23)
SERDES_1_INT_REFCLK_N: length 4.6
  TOP w0.254: U1.G20 v1(63.81,64.23)
  BOTTOM w0.127: v1(63.81,64.23) 63.98,64.07 64.2,64.07 64.82,63.46 67.4,63.46
SERDES_1_INT_REFCLK_P: length 5.8
  TOP w0.254: U1.G19 v1(62.81,64.23)
  BOTTOM w0.127: 67.4,63.13 64.68,63.13 64.07,63.74 63.31,63.74 v1(62.81,64.23)
SERDES_1_RX0_N: length 7.9
  TOP w0.127: U1.A19 62.65,70.07 62.65,70.76 63.52,71.63 68.99,71.63
SERDES_1_RX0_P: length 7.3
  TOP w0.127: U1.A20 62.98,70.07 62.98,70.62 63.66,71.3 68.99,71.3
SERDES_1_RX1_N: length 5.8
  TOP w0.254: U1.C19 v1(62.81,68.23)
  BOTTOM w0.127: v1(62.81,68.23) 63.31,67.74 64.07,67.74 64.68,67.13 67.4,67.13
SERDES_1_RX1_P: length 4.6
  TOP w0.254: U1.C20 v1(63.81,68.23)
  BOTTOM w0.127: 67.4,67.46 64.82,67.46 64.2,68.07 63.98,68.07 v1(63.81,68.23)
SERDES_1_RX2_N: length 5.1
  TOP w0.127: 69.17,65.23 64.81,65.23 U1.F21
SERDES_1_RX2_P: length 3.9
  TOP w0.127: U1.F22 65.48,64.9 69.17,64.9
SERDES_1_RX3_N: length 5.8
  TOP w0.254: U1.L19 v1(62.81,60.23)
  BOTTOM w0.127: v1(62.81,60.23) 63.31,59.74 64.07,59.74 64.68,59.13 67.4,59.13
SERDES_1_RX3_P: length 4.6
  TOP w0.254: U1.L20 v1(63.81,60.23)
  BOTTOM w0.127: 67.4,59.46 64.82,59.46 64.2,60.07 63.98,60.07 v1(63.81,60.23)
SERDES_1_TX0_N: length 5.1
  TOP w0.127: 69.17,69.23 64.81,69.23 U1.B21
SERDES_1_TX0_P: length 3.9
  TOP w0.127: 69.17,68.9 65.48,68.9 U1.B22
SERDES_1_TX1_N: length 5.1
  TOP w0.127: 69.17,67.23 64.81,67.23 U1.D21
SERDES_1_TX1_P: length 3.9
  TOP w0.127: 69.17,66.9 65.48,66.9 U1.D22
SERDES_1_TX2_N: length 5.1
  TOP w0.127: U1.H21 64.81,63.23 69.17,63.23
SERDES_1_TX2_P: length 3.9
  TOP w0.127: U1.H22 65.48,62.9 69.17,62.9
SERDES_1_TX3_N: length 5.1
  TOP w0.127: U1.K21 64.81,61.23 69.17,61.23
SERDES_1_TX3_P: length 3.9
  TOP w0.127: U1.K22 65.48,60.9 69.17,60.9
SERDES_13_EXT_REFCLK_N: length 4.6
  TOP w0.254: U1.E20 v1(63.81,66.23)
  BOTTOM w0.127: 67.4,65.46 64.82,65.46 64.2,66.07 63.98,66.07 v1(63.81,66.23)
SERDES_13_EXT_REFCLK_P: length 5.8
  TOP w0.254: U1.E19 v1(62.81,66.23)
  BOTTOM w0.127: 67.4,65.13 64.68,65.13 64.07,65.74 63.31,65.74 v1(62.81,66.23)
SERDES_VREF: length 1.4
  TOP w0.254: U1.D19 v1(62.81,67.23) ; U1.F19 v1(62.81,65.23)

## Text on the board
BOTTOM: Layer 14 (BOTTOM)
Ref Des/Assembly Bottom: ASSEMBLY_BOTTOM
Ref Des/Silkscreen Bottom: 305-PD-1X-XXXX | MICROSEMI TECHNICAL SUPPORT | +1(800) 262-1060
TOP: Layer 1 (TOP)
Ref Des/Assembly Top: ASSEMBLY_TOP
Ref Des/Silkscreen Top: RT4G_DEVELOPMENT_KIT REV A | DVP-101-000XXX-001
FAB_DATA: 4.0 MILS | 6.5 MILS | 50 OHM | SINGLE | 3.5/8.0 MILS | DIFFERENTIAL | 5 / 8 MILS | 100 OHM | 5.1 / 4.9 MILS | 90 OHM | REV | 1 | INTIAL RELEASE | DESCRIPTION | REVISIONS | XXXXXXXX | DATE | APPROVAL | 10.  VIAS IN THIS REGION NEEDS VIA PLUGGING FROM BOTTOM SIDE. | 14.  IMPEDANCE TOLERANCE SHOULD BE +/- 5% ON L1, L12, L14. REST OF THE LAYRES CAN HAVE 10% TOLERANCE | 11.  BOARD MUST BE UL 94V-1 APPROVED. | 12.  FABRICATE BOARD PER IPC-A-600D STANDARD. | 13.  CLIP SILKSCREEN ON NO MASK AREA. | 17.  REMOVE UNUSED PADS IN ALL INNER LAYERS. | 18.  BOARD DIMENSIONS ARE IN INCHES | 15.  NO VENDOR LOGO, ART WORKS SHOULD NOT BE | 20.  THIS IS A ROHS COMPLIANT BOARD | 19.  WARP & TWIST: SHALL NOT EXCEED 0.005 INCHES PER INCH | 2.1. SELECTIVE HARD GOLD PLATING TO BE FLAT & | 16.  DEBURR ALL SHARP EDGES | 21.  EDGE FINGER- CHAMFER EDGES MUST BE FREE OF CUTTING BURRS | 5.  SILKSCREEN BOTH SIDES, WHITE. | 7.  SOLDER MASK TOP AND BOTTOM SIDES WITH | 6.  FABRICATE PER DIMENSIONS SHOWN. | PLATING IN HOLES TO BE 0.001 MIN. THICK. | 4.  HOLE SIZES ARE AFTER PLATING. | 3.  HOLES TO BE PLATED THROUGH. | 9.  APPLY THIEVING AS REQUIRED. | 8.  TOTAL BOARD THICKNESS:  62 mil+/- 6 mil | SOLDER MASK.  COLOR GREEN. | LIQUID PHOTO IMAGABLE OR DRY FILM | 14 LAYER CONSTRUCTION. | 2.  GENERAL PLATING - FLASH GOLD | NOTES: UNLESS OTHERWISE SPECIFIED | 1.  MATERIAL: FR-4. | ABOVE THE SOLDER RESIST SURFACE ON TOP AND BOTTOM | THE VIAS SHOULD BE SMOOTHENED TO BOARD SURFACE ON TOP AND BOTTOM | GOLD PLATING ON PAD SHOULD BE THE SAME LEVEL OR | FOR SELECTIVE PLATING SEE BELOW | CHANGED WITHOUT PRIOR APPROVAL FROM PACTRON | PLATED 30uIN(MINIMUM) OF Au OVER 150-200uIN OF Ni. | NOTE: DIELECTRIC GLASS STYLE SHOULD NOT BE CHANGED WITHOUT PRIOR APPROVAL FROM PACTRON. | GLASS STYLE | DIELECTRIC | SHOULD NOT BE CHANGED FROM ABOVE STATED VALUES. | FINISHED TRACE WIDTH,AIR GAP OF 100 OHM DIFFERENTIAL AND 50 OHM SIGNLE ENDED | 2116 | STACKUP - 14 LAYERS | REFER STACKUP | CONTROLLED IMPEDANCE REQUIRED
User.17: FIGURE | SIZE | 125.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 2
User.19: DATE: | FILM LAYER: | NAME: | XXXXXXXX | XXXXXXXXXXXXXXXXXXXX | REV: | A | PACTRON
User.20: FAB | PROJECT NAME | PART NUMBER | PACTRON | DATE | 3000 PATRICK HENRY DRIVE, SANTA CLARA, CA 95054. | 408-329-5500(PHONE), 408-747-1239(FAX). | XXXXXXXXXXXXXXXXXXXXXX | DVP-101-000XXX-001 | XXXXXXXX | 305-PD-15-XXXX | REV : | A
User.23: DIELECTRIC (4.00 mils) | DIELECTRIC (4.50 mils) | DIELECTRIC (3.50 mils) | DIELECTRIC (2.00 mils) | TOP (1.40 mils) | L2_GND1 (0.60 mils) | L3_SIG1 (0.60 mils) | L4_GND2 (0.60 mils) | L5_SIG2 (0.60 mils) | L6_GND3 (0.60 mils) | L7_PWR1 (1.30 mils) | L8_PWR2 (1.30 mils) | L9_GND4 (0.60 mils) | L10_SIG3 (0.60 mils) | L11_GND5 (0.60 mils) | L12_SIG4 (0.60 mils) | L13_GND6 (0.60 mils) | BOTTOM (1.40 mils) | FR-4
